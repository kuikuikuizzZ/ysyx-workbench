## nemu/configs/riscv32-galois-npc_defconfig
```kconfig
CONFIG_TARGET_SHARE=y
# CONFIG_TRACE is not set
CONFIG_MSIZE=0x800000
CONFIG_HAS_INIT_MEM=y
```
